Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 5a11f066-a68e-44d5-835d-b64034e3aa5c, NumberOfSaves: 1]
File name: 0001
Time: 2024-09-13T15:19:09+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11997290_S_PWM907DV_SST:51907452_S_11997290_PWM907DV_SST, (2)
In: Default
Type - Material: z_Miele_Design_Orange, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, z_Miele_Design_Powder Coat_Grey, z_Miele_Design_Glass, Polypropylene, z_Miele_Design_Glass Black, <Unnamed>, z_Miele_Connection_Water_IN, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, z_Miele_Design_Powder Coat_Lotus White, Default
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 51907452_S_11997290_PWM907DV_SST; sets with these values: 2
